# IAR project ac_ac_conv.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: K1921VK01T NIIET K1921VK01T
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: K1921VK01T; OSECLK_VAL= 8000000; SYSCLK_PLL; CKO_NONE; RETARGET; RETARGET_USE_UART
  ICCARM.CCIncludePath2: ../platform/Device/NIIET/K1921VK01T/Include; ../platform/CMSIS/Core/Include; ../platform/retarget/Template/K1921VK01T; ../platform/retarget; MCU; StateMachine; D:\IAR_Projects\NIIET\ac_ac_converter\ac_ac_converter\Utility; std_lib; std_lib\Include; std_lib\Source; time; iqmath; iqmath\iar; Electrical; pt; $PROJ_DIR$; modbus; eeprom; Electrical\Sensors; TransferFunc; WorkClasses; TEST_SW
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: ac_ac_conv.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NIIET\K1921VK01T_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: CApp.cpp CApp.h config.cpp config.h main.cpp
    ../platform/retarget/: retarget.c
    ../platform/retarget/Template/K1921VK01T/: retarget_conf.c
    ../platform/Device/NIIET/K1921VK01T/Source/IAR/: startup_K1921VK01T.S
    ../platform/Device/NIIET/K1921VK01T/Source/: system_K1921VK01T.c
  group Eeprom
    eeprom/: eeprom.c eeprom.h eeprom_dummy.c eeprom_dummy.h
  group Electrical/Leds
    Electrical/: CLED.cpp CLED.h ILed.cpp ILed.h
  group Electrical/Sensors
    Electrical/Sensors/: CSensI.cpp CSensI.h CSensU.cpp CSensU.h ISens.cpp ISens.h
  group Electrical/Sensors/Sensors_FLOAT
    Electrical/Sensors/: CFSensI.cpp CFSensI.h CFSensU.h IFSens.cpp IFSens.h
  group Electrical/Sensors/Sensors_Template
    Electrical/Sensors/: TCSensI.h TISens.h
  group iqmath
    iqmath/: iqmath.h iqmath_float32.h iqmath_int32_mcu.h iqmath_int32_pc.h IQmathCPP.h IQmathLib.h
    iqmath/iar/: IQNasin.S IQNatan2.S IQNatan2PU.S IQNcos.S IQNcosPU.S IQNdiv.S IQNexp.S IQNexp2.S IQNfrac.S IQNint.S IQNisqrt.S IQNmag.S IQNmpy.S IQNmpyI32frac.S IQNmpyI32int.S IQNrmpy.S IQNrsmpy.S IQNsin.S IQNsinPU.S IQNsqrt.S IQNtoD.S IQNtoF.S IQtables.S IQxmpy.S
  group MCU
    MCU/: CADC.cpp CPin.cpp CPWM.cpp CSysTick.cpp CUART.cpp gpio.c gpio.h gpio_hw.c gpio_hw.h IPheriphery.cpp mcu.cpp uart1_gpio.c uart1_gpio.h uart1_hw.h uart1_hw_poll.c uart2_gpio.c uart2_gpio.h uart2_hw.h uart2_hw_poll.c uart_hw.c uart_hw.h watchdog.c watchdog.h
  group Modbus
    modbus/: modbus.h modbus2_rtu.c modbus2_rtu.h modbus_config.c modbus_config.h modbus_config_cb.h modbus_config_converter.cpp modbus_crc16.c modbus_crc16.h modbus_eeprom.c modbus_eeprom.h modbus_regs.c modbus_regs.h modbus_regs_alias.c modbus_regs_alias.h modbus_rtu.c modbus_rtu.h modbus_scope.c modbus_scope.h modbus_slave.c str_utils.c str_utils.h
  group PT
    pt/: lc-addrlabels.h lc-switch.h lc.h pt-sem.h pt.h
  group StateMachine
    StateMachine/: CCharge.cpp CCharge.h CDiag.cpp CDiag.h CFault.cpp CFault.h CInit.cpp CInit.h CReady.cpp CReady.h CRun.cpp CRun.h IState.cpp IState.h state_machine.cpp state_machine.h
  group STD_LIB
    std_lib/Source/: niietcm4_adc.c niietcm4_bootflash.c niietcm4_cap.c niietcm4_dma.c niietcm4_extmem.c niietcm4_gpio.c niietcm4_irq.c niietcm4_pwm.c niietcm4_rcc.c niietcm4_rtc.c niietcm4_timer.c niietcm4_uart.c niietcm4_userflash.c niietcm4_watchdog.c
  group TF
    TransferFunc/: filter.cpp filter.h integrator.cpp integrator.h itrans_func.cpp itrans_func.h piregulator.cpp piregulator.h prop_reg.cpp prop_reg.h
  group Time
    time/: clock.c clock.h time_defs.h timer.c timer.h
  group UTILITY
    Utility/: atomic.h aux_utility.h c_lang_adapter.cpp c_lang_adapter.h user_constants.cpp user_constants.h
  group WorkClasses
    WorkClasses/: CCmds.cpp CCmds.h CErrors.cpp CErrors.h
  group WorkClasses/TestSwitch
    TEST_SW/: CIgbt.cpp CIgbt.h CKM.cpp CKM.h IControlObj.h
