<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ac_ac_conv.ewp</path>
    </project>
    <batchBuild />
</workspace>
